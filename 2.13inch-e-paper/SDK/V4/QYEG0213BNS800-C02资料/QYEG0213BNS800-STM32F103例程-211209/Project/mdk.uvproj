# Keil uVision project mdk.uvproj, settings and files
target GDE (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: mdk +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,GDEP015OC1
  c include: ..\FWLib;..\User;..\StartUp;..\EPD_W21
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group FwLib
    ../FWLib/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_tim.c misc.c stm32f10x_iwdg.c
  group StartUp
    ../StartUp/: system_stm32f10x.c core_cm3.c stm32f10x_conf.h startup_stm32f10x_hd.s
  group User
    ../User/: stm32f10x_it.c main.c
  group EPD_W21
    ../EPD_W21/: EPAPER.c
